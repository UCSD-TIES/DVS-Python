// main.cp

#include "main.h"

BEGIN_MESSAGE_MAP( CMFCCameraSetupDlg, CDialog )
ON_NOTIFY_EX(TTN_NEEDTEXT, 0, OnToolTipText)
ON_BN_CLICKED(IDC_PREPARE_CAMERA_MANUAL_BUTTON, OnManualPressed)
END_MESSAGE_MAP()

CEyeDxBooleanType CMFCCameraSetupDlg::OnToolTipText(UINT, NMHDR* pNMHDR, LRESULT*)
{
	TOOLTIPTEXT *pTTT = (TOOLTIPTEXT *) pNMHDR;
	if (!(pTTT->uFlags & TTF_IDISHWND))	// the ID must be a handle to a window
		return FALSE;
		
	UINT uID = pNMHDR->idFrom;
	uID = ::GetDlgCtrlID((HWND)uID);
		
	CString strTipText;
	
	// Attempt to load a ToolTip string that corresponds to the control's ID
	
	if(!strTipText.LoadString(uID))
		return FALSE;
	
	// Stuff text into the ToolTip, 80 characters maximum
	
	strncpy(pTTT->lpszText, strTipText, 80);
	return TRUE;
}

CEyeDxBooleanType CMFCCameraSetupDlg::OnInitDialog()
{
	CDialog::OnInitDialog();
	CenterWindow();
		
	EnableToolTips(TRUE);	
		
	m_hCameraSetupBitmap.LoadBitmap("ID_CAMERA_SETUP_BITMAP");
	
	CStatic	*m_ctlCameraSetupBitmap = (CStatic *) GetDlgItem(IDC_PREPARE_CAMERA_BITMAP);
	
	m_ctlCameraSetupBitmap->SetBitmap(m_hCameraSetupBitmap);

	CStatic	*m_ManualCaption = (CStatic *) GetDlgItem(IDC_PREPARE_CAMERA_MANUAL_CAPTION);
	
	CStatic	*m_AutoCaption = (CStatic *) GetDlgItem(IDC_PREPARE_CAMERA_AUTO_CAPTION);
	
	CButton	*m_ManualButton = (CButton *) GetDlgItem(IDC_PREPARE_CAMERA_MANUAL_BUTTON);

	CButton	*m_OKButton = (CButton *) GetDlgItem(IDOK);

	if (m_AutoStart)
	{
		m_ManualCaption->ShowWindow(SW_HIDE);
		m_ManualButton->ShowWindow(SW_HIDE);
		m_AutoCaption->SetWindowText("Press Continue when camera is ready.");
		m_OKButton->SetWindowText("Continue");
	}
	
	return TRUE;
}

void CMFCCameraSetupDlg::OnManualPressed()
{
	EndDialog(IDC_PREPARE_CAMERA_MANUAL_BUTTON);
}
