// main.cp

#include "main.h"

#if defined (WIN32)
	#define IS_WIN32	TRUE
#else
	#define IS_WIN32	FALSE
#endif

BEGIN_MESSAGE_MAP( CMFCPasswordDlg, CDialog )
ON_NOTIFY_EX(TTN_NEEDTEXT, 0, OnToolTipText)
END_MESSAGE_MAP()

CEyeDxBooleanType CMFCPasswordDlg::OnToolTipText(UINT, NMHDR* pNMHDR, LRESULT*)
{
	TOOLTIPTEXT *pTTT = (TOOLTIPTEXT *) pNMHDR;
	if (!(pTTT->uFlags & TTF_IDISHWND))	// the ID must be a handle to a window
		return FALSE;
		
	UINT uID = pNMHDR->idFrom;
	uID = ::GetDlgCtrlID((HWND)uID);
		
	CString strTipText;
	
	// Attempt to load a ToolTip string that corresponds to the control's ID
	
	if(!strTipText.LoadString(uID))
		return FALSE;
	
	// Stuff text into the ToolTip, 80 characters maximum
	
	strncpy(pTTT->lpszText, strTipText, 80);
	return TRUE;
}

CEyeDxBooleanType CMFCPasswordDlg::OnInitDialog()
{
	CDialog::OnInitDialog();
	CenterWindow();
		
	EnableToolTips(TRUE);
	
	m_ctlPasswordField = (CEdit *) GetDlgItem(IDC_PASSWORD_FIELD);
	
	return TRUE;
}

void CMFCPasswordDlg::OnOK()
{
	CEyeDxLongStringType theEnteredPassword;
	CEyeDxLongStringType theActualPassword = CommonStringLiteral_(kPasswordString);

	CComDATE theCurrentDateTime = CComDATE::Now();
			
	CEyeDxLongStringType theDayNumber;
	theDayNumber.Format("%d", theCurrentDateTime.Day());
	
	theActualPassword = theActualPassword + theDayNumber;

	m_ctlPasswordField->GetWindowText(theEnteredPassword);	
	
	if (theEnteredPassword == theActualPassword)
		CDialog::OnOK();
	else
		Beep(100, 1);
}
